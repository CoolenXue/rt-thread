# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC2478 (ARM-GNU)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtthread-lpc24xx
  group Kernel
    ../../src/: clock.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c serial.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/lpc24xx/: cpu.c interrupt.c stack.c trap.c context_gcc.S start_gcc.S
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/minilibc/: ctype.c math.c qsort.c rand.c stdlib.c string.c time.c
